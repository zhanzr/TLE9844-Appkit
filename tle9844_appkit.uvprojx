# Keil uVision project tle9844_appkit.uvprojx, settings and files
target TLE9844_EvalBoard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TLE9844QX Infineon
  pack: Infineon.TLE984x_DFP.1.1.1
  cpu: IRAM(0x18000000,0x1000) IROM(0x11000000,0x10000) IROM2(0x10FFFFFC,4) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: tty
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: TLE9844_2QX,CPU_SYSTICK_EN=1
  c include: .\app
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x10000
  memory RVCT5: ROM 0x10fffffc size 0x4
  memory RVCT9: RAM 0x18000000 size 0x1000
  group App
    ./app/: main.c
  group doc
    ./: README.md
software components: CMSIS:CORE 5.1.2, Device:ConfigWizard 1.8.7, Device:SDK:ADC1 0.1.7, Device:SDK:ADC2 0.1.6, Device:SDK:BOOTROM 1.5.0, Device:SDK:INT 0.1.4, Device:SDK:ISR 0.1.8, Device:SDK:LS 0.1.4, Device:SDK:PORT 0.6.0, Device:SDK:SCU 0.3.2, Device:SDK:UART 0.1.4, Device:SDK:WDT1 0.2.5, Device:Startup 1.0.1, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
